# Keil uVision project IIC通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IIC通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\Public;.\User;.\App\24c02;.\App\iic;.\App\key;.\App\smg
  group User
    ./User/: main.c
  group App
    ./App/24c02/: 24c02.c
    ./App/iic/: iic.c
    ./App/key/: key.c
    ./App/smg/: smg.c
  group Public
    ./Public/: public.c
